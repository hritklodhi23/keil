# Keil uVision project MiniRTOS.uvprojx, settings and files
target MiniRTOS_Debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  group Kernel
    ../src/kernel/: rtos_kernel.c task_manager.c scheduler.c context_switch.c synchronization.c systick_handler.c
  group Application
    ../src/app/: main.c led_blink_app.c sync_example.c
  group Include
    ../src/include/: config.h
    ../src/kernel/: rtos_kernel.h task_manager.h scheduler.h context_switch.h synchronization.h systick_handler.h
